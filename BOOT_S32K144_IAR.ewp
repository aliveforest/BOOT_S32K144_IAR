# IAR project BOOT_S32K144_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; __ICCARM__
  ICCARM.CCIncludePath2: Sources; Sources\lib; Genrated_Code; SDK\linker; SDK\devices; SDK\devices\common; SDK\devices\S32K144\include; SDK\devices\S32K144\startup; SDK\drivers; SDK\drivers\inc; SDK\drivers\src; SDK\drivers\src\clock; SDK\drivers\src\clock\S32K1xx; SDK\drivers\src\flash; SDK\drivers\src\interrupt; SDK\drivers\src\power; SDK\drivers\src\power\S32K1xx; Generated_Code
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BOOT_S32K144_IAR.bin
  ILINK.IlinkOutputFile: BOOT_S32K144_IAR.out
  ILINK.IlinkIcfFile: D:\dengtongbei\IAR_works\BOOT_S32K144_IAR\SDK\linker\S32K144_64_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Genrated_Code
    Generated_Code/: clockMan1.c clockMan1.h Cpu.c Cpu.h Flash1.c Flash1.h pin_mux.c pin_mux.h
  group SDK/devices
    SDK/devices/: callbacks.h devassert.h device_registers.h startup.c startup.h status.h
  group SDK/devices/common
    SDK/devices/common/: s32_core_cm4.h
  group SDK/devices/S32K144/include
    SDK/devices/S32K144/include/: S32K144.h S32K144_features.h
  group SDK/devices/S32K144/startup
    SDK/devices/S32K144/startup/: startup_S32K144.s system_S32K144.c system_S32K144.h
  group SDK/drivers/inc
    SDK/drivers/inc/: clock.h clock_manager.h flash_driver.h interrupt_manager.h pins_driver.h
  group SDK/drivers/src/clock/S32K1xx
    SDK/drivers/src/clock/S32K1xx/: clock_S32K1xx.c clock_S32K1xx.h pcc_hw_access.h pmc_hw_access.h scg_hw_access.h sim_hw_access.h smc_hw_access.h
  group SDK/drivers/src/flash
    SDK/drivers/src/flash/: flash_driver.c
  group SDK/drivers/src/interrupt
    SDK/drivers/src/interrupt/: interrupt_manager.c
  group SDK/drivers/src/pins
    SDK/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
  group SDK/drivers/src/power
    SDK/drivers/src/power/: power_manager.c
  group SDK/drivers/src/power/S32K1xx
    SDK/drivers/src/power/S32K1xx/: power_manager_S32K1xx.c power_manager_S32K1xx.h power_rcm_hw_access.h power_scg_hw_access.h power_smc_hw_access.c power_smc_hw_access.h
  group SDK/linker
    SDK/linker/: S32K144_64_flash.icf S32K144_64_ram.icf
  group Sources
    Sources/: main.c
  group Sources/lib
    Sources/lib/: FlashWriteRead.c FlashWriteRead.h latency.c latency.h LPUART.c LPUART.h RGB_LED.c RGB_LED.h Ymodem.c Ymodem.h
